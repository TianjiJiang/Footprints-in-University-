# Keil uVision project NO1_module_test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: NO1_module_test +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c serial.c feed_motor.c lcd.c ultrasonic.c mem.c RTC.c common.c HX711.c CmdPro.c
